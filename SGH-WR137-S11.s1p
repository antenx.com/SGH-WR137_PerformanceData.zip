# Hz S DB R 50
! HP 8720B Vector Network Analyzer
! S-Parameter: S11
! Start Frequency: 510 MHz
! Stop Frequency: 17990 MHz
! Number of Points: 401
! Date: 21-Aug-2022 10:01:10
! Worked out from all points (one-port):
!   401 points, 510 MHz to 17.99 GHz, reference 50 ohm
!   lowest |S11| = -46.8 dB at 7.939 GHz (marker M1), VSWR 1.01, Z = 50.4 - j0.104 ohm
!   |S11| at or under -10 dB: 5.229 GHz to 10.83 GHz (5.602 GHz wide, 69.8 % of centre); 14.53 GHz to 14.64 GHz (111.1 MHz wide, 0.762 % of centre); 14.71 GHz to 16.03 GHz (1.321 GHz wide, 8.59 % of centre) (the widest 3 of 10)
!   the Smith chart shows 6.497 GHz to 8.988 GHz only
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! magnitudes (dB):
! f  S11
! 510 MHz  -10.0
! 1.253 GHz  -5.4
! 2.695 GHz  -3.5
! 4.268 GHz  -3.9
! 4.88 GHz  -7.2
! 5.404 GHz  -11.1
! 5.71 GHz  -15.0
! 5.973 GHz  -16.2
! 6.191 GHz  -24.7
! 6.497 GHz  -19.3
! 6.803 GHz  -27.7
! 7.065 GHz  -20.2
! 7.327 GHz  -29.5
! 7.589 GHz  -21.9
! 7.721 GHz  -28.3
! 7.852 GHz  -24.8
! 7.939 GHz  -46.8
! 8.026 GHz  -20.2
! 8.114 GHz  -24.9
! 8.551 GHz  -22.8
! 8.944 GHz  -18.8
! 9.25 GHz  -15.7
! 11.44 GHz  -8.9
! 13.01 GHz  -6.8
! 13.62 GHz  -9.0
! 15.8 GHz  -13.0
! 16.46 GHz  -8.7
! 17.99 GHz  -7.3
